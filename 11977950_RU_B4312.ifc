Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-12-14T11:32:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 14 11:32:49 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{C39E0850-1E5E-4394-9598-9D39962A6D8C}\ifc * Database version: 5507 * Database creation date: Tue Dec 14 11:32:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 14 11:32:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 14 11:32:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 13431221_RU_11977950_B4312, 11977950_RU_B4312:13431221_RU_11977950_B4312:207001
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Connection_Dampf, z_Miele_Design_BRWS, z_Miele_Design_CLST, SAN Plastic, z_Miele_Design_Cast, z_Miele_Design_Alusilver, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 13431221_RU_11977950_B4312
